simulink model "BipedRobot_SILS"  (R2016b)
settings: Solver=ode23tb  StartTime=0.0  StopTime=Tend  FixedStep=0.001  RelTol=1e-4  EnableMultiTasking=on
PreLoadFcn:
  | BipedRobot_param
  | load walk_forward
  | eta = 1;
  | N = 40;
values from neighbouring files (symbols this model uses):
  A = [1 0 0 0 0 0    [symbolic_sample.m]
  bn = 50    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  bt = 50    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  kn = 5000    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  kt = 5000    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  mu_d = 0.8    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  mu_s = 2    [BipedRobot_param.m]    (also in SimpleContact_param.m)
  s = robot_para.s    [kinematics_calc.m]    (also in plot_graph.m; robot_parameter.m = 40; robot_view.m)
  Ts = walk_para.Ts    [Angular_Vel_Acc_calc_forward.m]    (also in main.m; reference_orbit.m; reference_orbit_acc.m; Vel_Acc_calc_forward.m)
  zvt = 1e-3    (= 0.001)    [BipedRobot_param.m]    (also in SimpleContact_param.m)
undefined symbols (not defined in the file or in its folder): arm, bridge, constant, deg, Inertia, KD, kg, KI, KP, m, Mass, powergui, pulses, rad, S, Torque
libraries: mblibv1 x90, powerlib x7, simulink x2, powerlib_extras x1
(part 3 of 3)

== stateflow chart BipedRobot_SILS/LL0/Contact1/Contact
Force/Chart ==
  state No_Contact/
    state 非接触状態 [group]
    (default) -> (junction 48) : { mode = 1;  /* 垂直力、摩擦力ともにゼロ */ Fn = 0; Fx = 0; Fy = 0; }
  state Sticking/
    state 固着状態 [group]
    Sticking -> (junction 53) : { /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 52) : { mode = 4;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 52) -> (junction 53)
    (junction 53) -> (junction 54) : [ Fn < 0 ]
    (junction 53) -> (junction 41) : { /* 静止摩擦力計算 */ Fx = -(kt*(px-ax)+bt*dpx); Fy = -(kt*(py-ay)+bt*dpy);  /* 摩擦力ベクトルの大きさ */ norm_Ft = sqrt(Fx^2+Fy^2); }
    (junction 54) -> (junction 47) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 41) -> (junction 40) : [ norm_Ft > mu_s*Fn ]
    (junction 41) -> (junction 39)
    (junction 40) -> (junction 38) : { mode = 5;  /* 静止摩擦力計算 */ Fx = -mu_s*Fn*Fx/norm_Ft; Fy = -mu_s*Fn*Fy/norm_Ft; }
    (junction 38) -> (junction 39)
    (junction 47) -> (junction 38)
    (junction 39) -> (junction 56)
  state Sliding/
    state 滑り状態 [group]
    Sliding -> (junction 43) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 42) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 42) -> (junction 43)
    (junction 43) -> (junction 44) : [ Fn < 0 ]
    (junction 43) -> (junction 45) : { /* 接線方向速度ベクトルの大きさ */ norm_dpt = sqrt(dpx^2+dpy^2); }
    (junction 44) -> (junction 46) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 45) -> (junction 49) : [ norm_dpt <= zvt ]
    (junction 45) -> (junction 51) : { /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/norm_dpt; Fy = -mu_d*Fn*dpy/norm_dpt; }
    (junction 49) -> (junction 50) : { mode = 3;  /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/zvt; Fy = -mu_d*Fn*dpy/zvt;  /* アンカーポイント設定 */ ax = px; ay = py; }
    (junction 50) -> (junction 51)
    (junction 46) -> (junction 50)
    (junction 51) -> (junction 55)
  (default) -> No_Contact
  Sliding -> No_Contact : [pn >= 0 ]
  No_Contact -> Sliding : [ pn < 0 ]
  Sticking -> No_Contact : [ pn >= 0 ]
  Sliding -> Sticking : [ pn < 0 ... && mode == 3 ]
  Sticking -> Sliding : [ pn < 0 ... && (mode == 5 || mode == 6) ]
  data: Fx output double; Fy output double; kn input =kn; kt input =kt; bn input =bn; bt input =bt; mu_d input =mu_d; mu_s input =mu_s; zvt input =zvt; px input; py input; pn input; dpx input; dpy input; Fn output double; dpn input; norm_dpt local double; norm_Ft local double; mode output double; ax local double; ay local double

== stateflow chart BipedRobot_SILS/LL0/Contact2/Contact
Force/Chart ==
  state No_Contact/
    state 非接触状態 [group]
    (default) -> (junction 48) : { mode = 1;  /* 垂直力、摩擦力ともにゼロ */ Fn = 0; Fx = 0; Fy = 0; }
  state Sticking/
    state 固着状態 [group]
    Sticking -> (junction 53) : { /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 52) : { mode = 4;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 52) -> (junction 53)
    (junction 53) -> (junction 54) : [ Fn < 0 ]
    (junction 53) -> (junction 41) : { /* 静止摩擦力計算 */ Fx = -(kt*(px-ax)+bt*dpx); Fy = -(kt*(py-ay)+bt*dpy);  /* 摩擦力ベクトルの大きさ */ norm_Ft = sqrt(Fx^2+Fy^2); }
    (junction 54) -> (junction 47) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 41) -> (junction 40) : [ norm_Ft > mu_s*Fn ]
    (junction 41) -> (junction 39)
    (junction 40) -> (junction 38) : { mode = 5;  /* 静止摩擦力計算 */ Fx = -mu_s*Fn*Fx/norm_Ft; Fy = -mu_s*Fn*Fy/norm_Ft; }
    (junction 38) -> (junction 39)
    (junction 47) -> (junction 38)
    (junction 39) -> (junction 56)
  state Sliding/
    state 滑り状態 [group]
    Sliding -> (junction 43) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 42) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 42) -> (junction 43)
    (junction 43) -> (junction 44) : [ Fn < 0 ]
    (junction 43) -> (junction 45) : { /* 接線方向速度ベクトルの大きさ */ norm_dpt = sqrt(dpx^2+dpy^2); }
    (junction 44) -> (junction 46) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 45) -> (junction 49) : [ norm_dpt <= zvt ]
    (junction 45) -> (junction 51) : { /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/norm_dpt; Fy = -mu_d*Fn*dpy/norm_dpt; }
    (junction 49) -> (junction 50) : { mode = 3;  /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/zvt; Fy = -mu_d*Fn*dpy/zvt;  /* アンカーポイント設定 */ ax = px; ay = py; }
    (junction 50) -> (junction 51)
    (junction 46) -> (junction 50)
    (junction 51) -> (junction 55)
  (default) -> No_Contact
  Sliding -> No_Contact : [pn >= 0 ]
  No_Contact -> Sliding : [ pn < 0 ]
  Sticking -> No_Contact : [ pn >= 0 ]
  Sliding -> Sticking : [ pn < 0 ... && mode == 3 ]
  Sticking -> Sliding : [ pn < 0 ... && (mode == 5 || mode == 6) ]
  data: Fx output double; Fy output double; kn input =kn; kt input =kt; bn input =bn; bt input =bt; mu_d input =mu_d; mu_s input =mu_s; zvt input =zvt; px input; py input; pn input; dpx input; dpy input; Fn output double; dpn input; norm_dpt local double; norm_Ft local double; mode output double; ax local double; ay local double

== stateflow chart BipedRobot_SILS/LL0/Contact3/Contact
Force/Chart ==
  state No_Contact/
    state 非接触状態 [group]
    (default) -> (junction 48) : { mode = 1;  /* 垂直力、摩擦力ともにゼロ */ Fn = 0; Fx = 0; Fy = 0; }
  state Sticking/
    state 固着状態 [group]
    Sticking -> (junction 53) : { /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 52) : { mode = 4;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 52) -> (junction 53)
    (junction 53) -> (junction 54) : [ Fn < 0 ]
    (junction 53) -> (junction 41) : { /* 静止摩擦力計算 */ Fx = -(kt*(px-ax)+bt*dpx); Fy = -(kt*(py-ay)+bt*dpy);  /* 摩擦力ベクトルの大きさ */ norm_Ft = sqrt(Fx^2+Fy^2); }
    (junction 54) -> (junction 47) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 41) -> (junction 40) : [ norm_Ft > mu_s*Fn ]
    (junction 41) -> (junction 39)
    (junction 40) -> (junction 38) : { mode = 5;  /* 静止摩擦力計算 */ Fx = -mu_s*Fn*Fx/norm_Ft; Fy = -mu_s*Fn*Fy/norm_Ft; }
    (junction 38) -> (junction 39)
    (junction 47) -> (junction 38)
    (junction 39) -> (junction 56)
  state Sliding/
    state 滑り状態 [group]
    Sliding -> (junction 43) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 42) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 42) -> (junction 43)
    (junction 43) -> (junction 44) : [ Fn < 0 ]
    (junction 43) -> (junction 45) : { /* 接線方向速度ベクトルの大きさ */ norm_dpt = sqrt(dpx^2+dpy^2); }
    (junction 44) -> (junction 46) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 45) -> (junction 49) : [ norm_dpt <= zvt ]
    (junction 45) -> (junction 51) : { /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/norm_dpt; Fy = -mu_d*Fn*dpy/norm_dpt; }
    (junction 49) -> (junction 50) : { mode = 3;  /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/zvt; Fy = -mu_d*Fn*dpy/zvt;  /* アンカーポイント設定 */ ax = px; ay = py; }
    (junction 50) -> (junction 51)
    (junction 46) -> (junction 50)
    (junction 51) -> (junction 55)
  (default) -> No_Contact
  Sliding -> No_Contact : [pn >= 0 ]
  No_Contact -> Sliding : [ pn < 0 ]
  Sticking -> No_Contact : [ pn >= 0 ]
  Sliding -> Sticking : [ pn < 0 ... && mode == 3 ]
  Sticking -> Sliding : [ pn < 0 ... && (mode == 5 || mode == 6) ]
  data: Fx output double; Fy output double; kn input =kn; kt input =kt; bn input =bn; bt input =bt; mu_d input =mu_d; mu_s input =mu_s; zvt input =zvt; px input; py input; pn input; dpx input; dpy input; Fn output double; dpn input; norm_dpt local double; norm_Ft local double; mode output double; ax local double; ay local double

== stateflow chart BipedRobot_SILS/LL0/Contact4/Contact
Force/Chart ==
  state No_Contact/
    state 非接触状態 [group]
    (default) -> (junction 48) : { mode = 1;  /* 垂直力、摩擦力ともにゼロ */ Fn = 0; Fx = 0; Fy = 0; }
  state Sticking/
    state 固着状態 [group]
    Sticking -> (junction 53) : { /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 52) : { mode = 4;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 52) -> (junction 53)
    (junction 53) -> (junction 54) : [ Fn < 0 ]
    (junction 53) -> (junction 41) : { /* 静止摩擦力計算 */ Fx = -(kt*(px-ax)+bt*dpx); Fy = -(kt*(py-ay)+bt*dpy);  /* 摩擦力ベクトルの大きさ */ norm_Ft = sqrt(Fx^2+Fy^2); }
    (junction 54) -> (junction 47) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 41) -> (junction 40) : [ norm_Ft > mu_s*Fn ]
    (junction 41) -> (junction 39)
    (junction 40) -> (junction 38) : { mode = 5;  /* 静止摩擦力計算 */ Fx = -mu_s*Fn*Fx/norm_Ft; Fy = -mu_s*Fn*Fy/norm_Ft; }
    (junction 38) -> (junction 39)
    (junction 47) -> (junction 38)
    (junction 39) -> (junction 56)
  state Sliding/
    state 滑り状態 [group]
    Sliding -> (junction 43) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (default) -> (junction 42) : { mode = 2;  /* 垂直力計算 */ Fn = -(kn*pn+bn*dpn); }
    (junction 42) -> (junction 43)
    (junction 43) -> (junction 44) : [ Fn < 0 ]
    (junction 43) -> (junction 45) : { /* 接線方向速度ベクトルの大きさ */ norm_dpt = sqrt(dpx^2+dpy^2); }
    (junction 44) -> (junction 46) : { mode = 6;  /* 垂直力が負のときの処理 垂直力、摩擦力をゼロへ */ Fn = 0; Fx = 0; Fy = 0; }
    (junction 45) -> (junction 49) : [ norm_dpt <= zvt ]
    (junction 45) -> (junction 51) : { /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/norm_dpt; Fy = -mu_d*Fn*dpy/norm_dpt; }
    (junction 49) -> (junction 50) : { mode = 3;  /* 動摩擦力計算 */ Fx = -mu_d*Fn*dpx/zvt; Fy = -mu_d*Fn*dpy/zvt;  /* アンカーポイント設定 */ ax = px; ay = py; }
    (junction 50) -> (junction 51)
    (junction 46) -> (junction 50)
    (junction 51) -> (junction 55)
  (default) -> No_Contact
  Sliding -> No_Contact : [pn >= 0 ]
  No_Contact -> Sliding : [ pn < 0 ]
  Sticking -> No_Contact : [ pn >= 0 ]
  Sliding -> Sticking : [ pn < 0 ... && mode == 3 ]
  Sticking -> Sliding : [ pn < 0 ... && (mode == 5 || mode == 6) ]
  data: Fx output double; Fy output double; kn input =kn; kt input =kt; bn input =bn; bt input =bt; mu_d input =mu_d; mu_s input =mu_s; zvt input =zvt; px input; py input; pn input; dpx input; dpy input; Fn output double; dpn input; norm_dpt local double; norm_Ft local double; mode output double; ax local double; ay local double
